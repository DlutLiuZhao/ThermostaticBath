# Keil uVision project ThermostaticBath.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: ThermostaticBath +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\config;.\collection;.\display;.\userInput
  group ThermostaticBath
    ./: main.c
  group display
    ./display/: led.c lcd12864.c
  group userInput
    ./userInput/: key.c uart.c
  group config
    ./config/: delay.c
